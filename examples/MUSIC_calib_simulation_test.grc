options:
  parameters:
    generate_options: qt_gui
    id: run_MUSIC_calib_lin_array_simulation
    output_language: python
  states: {}

blocks:
- name: amv0
  id: variable
  parameters:
    value: numpy.multiply(ant_coeffs, amv0_true)
  states: {}
- name: amv0_true
  id: variable
  parameters:
    value: numpy.exp(-1j*ant_locs*2*numpy.pi*numpy.cos(theta0))
  states: {}
- name: amv1
  id: variable
  parameters:
    value: numpy.multiply(ant_coeffs, amv1_true)
  states: {}
- name: amv1_true
  id: variable
  parameters:
    value: numpy.exp(-1j*ant_locs*2*numpy.pi*numpy.cos(theta1))
  states: {}
- name: ant_coeffs
  id: variable
  parameters:
    comment: |-
      These simulated antenna coefficients need 
      to be the same as those used in 
      apps/run_calib_lin_array_simulation.grc
    value: ant_gains*numpy.exp(1j*ant_phases)
  states: {}
- name: ant_gains
  id: variable
  parameters:
    value: numpy.array([ 0.94984789,  0.4544107 ,  0.34649469,  0.25083929])
  states: {}
- name: ant_locs
  id: variable
  parameters:
    value: numpy.dot(0.5, numpy.arange(num_array_elements/2, -num_array_elements/2, -1) if (num_array_elements%2==1) else numpy.arange(num_array_elements/2-0.5, -num_array_elements/2-0.5, -1))
  states: {}
- name: ant_phases
  id: variable
  parameters:
    value: numpy.array([ 0.28647672,  5.27248071,  2.71271102,  1.36970886])
  states: {}
- name: antenna_calibration
  id: variable
  parameters:
    value: '"calibration_lin_array_simulated.cfg"'
  states: {}
- name: antenna_calibration_file_name
  id: variable
  parameters:
    value: os.path.join(directory_config_files, antenna_calibration)
  states: {}
- name: array_manifold_matrix
  id: variable
  parameters:
    value: numpy.array([amv0, amv1]).transpose()
  states: {}
- name: directory_config_files
  id: variable
  parameters:
    value: '"/home/rtp/rtp/GNU-Radio/gr-CARES/examples"'
  states: {}
- name: input_variables
  id: variable_struct
  parameters:
    comment: |-
      input_variables: 
      Contains all the user-defined variables.
    field0: SampleRate
    field1: ToneFreq1
    field10: AntPhases
    field11: DirectoryConfigFiles
    field12: AntennaCalibration
    field2: ToneFreq2
    field3: NormSpacing
    field4: NumTargets
    field5: NumArrayElements
    field6: PSpectrumLength
    field7: SnapshotSize
    field8: OverlapSize
    field9: AntGains
    value0: '320000'
    value1: '10000'
    value10: numpy.array([ 0.28647672,  5.27248071,  2.71271102,  1.36970886])
    value11: '"/tmp"'
    value12: '"calibration_lin_array_simulated.cfg"'
    value2: '20000'
    value3: '0.5'
    value4: '2'
    value5: '4'
    value6: 2**10
    value7: 2**11
    value8: 2**9
    value9: numpy.array([ 0.94984789,  0.4544107 ,  0.34649469,  0.25083929])
  states: {}
- name: norm_spacing
  id: variable
  parameters:
    value: '0.500'
  states: {}
- name: num_array_elements
  id: variable
  parameters:
    value: '4'
  states: {}
- name: num_targets
  id: variable
  parameters:
    value: '2'
  states: {}
- name: overlap_size
  id: variable
  parameters:
    value: '512'
  states: {}
- name: pspectrum_length
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: '320000'
  states: {}
- name: snapshot_size
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: theta0
  id: variable
  parameters:
    value: numpy.pi*theta0_deg/180
  states: {}
- name: theta0_deg
  id: variable_qtgui_range
  parameters:
    label: AoA
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '180'
    value: '30'
  states: {}
- name: theta1
  id: variable
  parameters:
    value: numpy.pi*theta1_deg/180
  states: {}
- name: theta1_deg
  id: variable_qtgui_range
  parameters:
    label: AoA
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '180'
    value: '123'
  states: {}
- name: tone_freq_1
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: tone_freq_2
  id: variable
  parameters:
    value: '20000'
  states: {}
- name: CARES_antenna_correction_0
  id: CARES_antenna_correction
  parameters:
    config_filename: /home/rtp/rtp/GNU-Radio/gr-CARES/calibration_lin_array_simulated.cfg
    num_inputs: num_array_elements
  states: {}
- name: CARES_find_local_max_0
  id: CARES_find_local_max
  parameters:
    num_max_vals: num_targets
    vector_len: pspectrum_length
    x_max: '180.0'
    x_min: '0.0'
  states: {}
- name: analog_noise_source_x_0_0
  id: analog_noise_source_x
  parameters:
    amp: '0.0005'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_noise_source_x_0_0_0
  id: analog_noise_source_x
  parameters:
    amp: '0.5'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '10000'
    offset: '0'
    phase: '0'
    samp_rate: sample_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: tone_freq_2
    offset: '0'
    phase: '0'
    samp_rate: sample_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: aoa_MUSIC_lin_array_0
  id: aoa_MUSIC_lin_array
  parameters:
    norm_spacing: norm_spacing
    num_inputs: num_array_elements
    num_targets: num_targets
    pspectrum_len: pspectrum_length
  states: {}
- name: aoa_autocorrelate_0
  id: aoa_autocorrelate
  parameters:
    avg_method: '1'
    num_inputs: num_array_elements
    overlap_size: overlap_size
    snapshot_size: snapshot_size
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_matrix_xx_0
  id: blocks_multiply_matrix_xx
  parameters:
    A: array_manifold_matrix
    tag_propagation_policy: gr.TPP_ALL_TO_ALL
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
    vlen: num_targets
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: sample_rate
    type: complex
  states: {}
- name: blocks_vector_to_streams_0
  id: blocks_vector_to_streams
  parameters:
    num_streams: num_targets
    type: float
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import os
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    grid: 'True'
    gui_hint: tab@0
    showports: 'True'
    update_time: '0.05'
    vlen: pspectrum_length
    width1: '2'
    x_axis_label: '"angle (in degrees)"'
    x_start: '0'
    x_step: 180.0/pspectrum_length
    y_axis_label: '"Pseudo-Spectrum (dB)"'
    ymax: '0'
    ymin: '-50'
  states: {}
- name: tab
  id: qtgui_tab_widget
  parameters:
    label0: Pseudo-Spectrum
    label1: Direction of Arrival
    label2: Direction of Arrival
    num_tabs: '3'
  states: {}

connections:
- [CARES_antenna_correction_0, '0', aoa_autocorrelate_0, '0']
- [CARES_antenna_correction_0, '1', aoa_autocorrelate_0, '1']
- [CARES_antenna_correction_0, '2', aoa_autocorrelate_0, '2']
- [CARES_antenna_correction_0, '3', aoa_autocorrelate_0, '3']
- [CARES_find_local_max_0, '0', blocks_null_sink_0, '0']
- [CARES_find_local_max_0, '1', blocks_vector_to_streams_0, '0']
- [analog_noise_source_x_0_0, '0', blocks_add_xx_0, '1']
- [analog_noise_source_x_0_0_0, '0', blocks_add_xx_0_0, '1']
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_add_xx_0_0, '0']
- [aoa_MUSIC_lin_array_0, '0', CARES_find_local_max_0, '0']
- [aoa_MUSIC_lin_array_0, '0', qtgui_vector_sink_f_0, '0']
- [aoa_autocorrelate_0, '0', aoa_MUSIC_lin_array_0, '0']
- [blocks_add_xx_0, '0', blocks_multiply_matrix_xx_0, '0']
- [blocks_add_xx_0_0, '0', blocks_throttle_0_0, '0']
- [blocks_multiply_matrix_xx_0, '0', CARES_antenna_correction_0, '0']
- [blocks_multiply_matrix_xx_0, '1', CARES_antenna_correction_0, '1']
- [blocks_multiply_matrix_xx_0, '2', CARES_antenna_correction_0, '2']
- [blocks_multiply_matrix_xx_0, '3', CARES_antenna_correction_0, '3']
- [blocks_throttle_0_0, '0', blocks_multiply_matrix_xx_0, '1']
- [blocks_vector_to_streams_0, '0', qtgui_number_sink_0, '0']
- [blocks_vector_to_streams_0, '1', qtgui_number_sink_1, '0']

metadata:
  file_format: 1
