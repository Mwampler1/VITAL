options:
  parameters:
    generate_options: no_gui
    id: run_calib_lin_array_simulation
    output_language: python
    run_options: run
  states: {}

blocks:
- name: amv0
  id: variable
  parameters:
    value: numpy.multiply(ant_coeffs, amv0_true)
  states: {}
- name: amv0_true
  id: variable
  parameters:
    value: numpy.exp(-1j*ant_locs*2*numpy.pi*numpy.cos(pilot_theta0))
  states: {}
- name: ant_coeffs
  id: variable
  parameters:
    value: ant_gains*numpy.exp(1j*ant_phases)
  states: {}
- name: ant_gains
  id: variable
  parameters:
    value: numpy.array([ 0.94984789,  0.4544107 ,  0.34649469,  0.25083929])
  states: {}
- name: ant_locs
  id: variable
  parameters:
    value: numpy.dot(0.5, numpy.arange(num_array_elements/2, -input_variables.NumArrayElements/2, -1) if (num_array_elements%2==1) else numpy.arange(num_array_elements/2-0.5, -num_array_elements/2-0.5, -1))
  states: {}
- name: ant_phases
  id: variable
  parameters:
    value: numpy.array([ 0.28647672,  5.27248071,  2.71271102,  1.36970886])
  states: {}
- name: antenna_calibration
  id: variable
  parameters:
    value: '"calibration_lin_array_simulated.cfg"'
  states: {}
- name: antenna_calibration_file_name
  id: variable
  parameters:
    value: os.path.join(directory_config_files, antenna_calibration)
  states: {}
- name: array_manifold_matrix
  id: variable
  parameters:
    value: numpy.array([amv0]).transpose()
  states: {}
- name: directory_config_files
  id: variable
  parameters:
    value: '"/home/rtp/rtp/GNU-Radio/gr-CARES/examples/"'
  states: {}
- name: input_variables
  id: variable_struct
  parameters:
    comment: |-
      input_variables: 
      Contains all the user-defined variables.
    field0: SampleRate
    field1: ToneFreq1
    field10: PilotAngleDegrees
    field11: DirectoryConfigFiles
    field12: AntennaCalibration
    field13: Samples2Avg
    field2: ToneFreq2
    field3: NormSpacing
    field4: NumArrayElements
    field5: PSpectrumLength
    field6: SnapshotSize
    field7: OverlapSize
    field8: AntGains
    field9: AntPhases
    value0: '3200000'
    value1: '10000'
    value10: '30.0'
    value11: '"/tmp"'
    value12: '"calibration_lin_array_simulated.cfg"'
    value13: 2**11
    value2: '20000'
    value3: '0.5'
    value4: '4'
    value5: 2**10
    value6: 2**11
    value7: 2**9
    value8: numpy.array([ 0.94984789,  0.4544107 ,  0.34649469,  0.25083929])
    value9: numpy.array([ 0.28647672,  5.27248071,  2.71271102,  1.36970886])
  states: {}
- name: norm_spacing
  id: variable
  parameters:
    value: '0.500'
  states: {}
- name: num_array_elements
  id: variable
  parameters:
    value: '4'
  states: {}
- name: num_targets
  id: variable
  parameters:
    value: '2'
  states: {}
- name: overlap_size
  id: variable
  parameters:
    value: '512'
  states: {}
- name: pilot_angle_degrees
  id: variable
  parameters:
    value: '30'
  states: {}
- name: pilot_theta0
  id: variable
  parameters:
    value: numpy.pi*pilot_angle_degrees/180
  states: {}
- name: pspectrum_length
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: '320000'
  states: {}
- name: samples_2_avg
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: snapshot_size
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: tone_freq_1
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: tone_freq_2
  id: variable
  parameters:
    value: '20000'
  states: {}
- name: CARES_calibrate_lin_array_0
  id: CARES_calibrate_lin_array
  parameters:
    norm_spacing: norm_spacing
    num_ant_ele: num_array_elements
    pilot_angle: pilot_angle_degrees
  states: {}
- name: CARES_save_antenna_calib_0
  id: CARES_save_antenna_calib
  parameters:
    config_filename: calibration_lin_array_simulated.cfg
    num_inputs: num_array_elements
    samples_to_average: samples_2_avg
  states: {}
- name: analog_noise_source_x_0_0_0
  id: analog_noise_source_x
  parameters:
    amp: '0.5'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: tone_freq_2
    offset: '0'
    phase: '0'
    samp_rate: sample_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: aoa_autocorrelate_0
  id: aoa_autocorrelate
  parameters:
    avg_method: '0'
    num_inputs: num_array_elements
    overlap_size: overlap_size
    snapshot_size: snapshot_size
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_magphase_0
  id: blocks_complex_to_magphase
  parameters:
    vlen: num_array_elements
  states: {}
- name: blocks_multiply_matrix_xx_0
  id: blocks_multiply_matrix_xx
  parameters:
    A: array_manifold_matrix
    tag_propagation_policy: gr.TPP_ALL_TO_ALL
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: sample_rate
    type: complex
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import os
  states: {}

connections:
- [CARES_calibrate_lin_array_0, '0', blocks_complex_to_magphase_0, '0']
- [analog_noise_source_x_0_0_0, '0', blocks_add_xx_0_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_add_xx_0_0, '0']
- [aoa_autocorrelate_0, '0', CARES_calibrate_lin_array_0, '0']
- [blocks_add_xx_0_0, '0', blocks_throttle_0_0, '0']
- [blocks_complex_to_magphase_0, '0', CARES_save_antenna_calib_0, '0']
- [blocks_complex_to_magphase_0, '1', CARES_save_antenna_calib_0, '1']
- [blocks_multiply_matrix_xx_0, '0', aoa_autocorrelate_0, '0']
- [blocks_multiply_matrix_xx_0, '1', aoa_autocorrelate_0, '1']
- [blocks_multiply_matrix_xx_0, '2', aoa_autocorrelate_0, '2']
- [blocks_multiply_matrix_xx_0, '3', aoa_autocorrelate_0, '3']
- [blocks_throttle_0_0, '0', blocks_multiply_matrix_xx_0, '0']

metadata:
  file_format: 1
