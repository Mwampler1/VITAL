options:
  parameters:
    generate_options: qt_gui
    id: FMCOMMS5_ura_attempt
    output_language: python
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: '2450000000'
  states: {}
- name: directory_config_files
  id: variable
  parameters:
    value: '"/tmp"'
  states: {}
- name: gain
  id: variable
  parameters:
    value: '60'
  states: {}
- name: input_variables
  id: variable_struct
  parameters:
    comment: |-
      input_variables: 
      Contains all the user-defined variables.
    field0: ToneFreq
    field1: SampleRate
    field10: PSpectrumLength
    field11: DirectoryConfigFiles
    field12: RelativePhaseOffsets
    field2: CenterFreq
    field3: RxAddr
    field4: Gain
    field5: NumArrayElements
    field6: NormSpacing
    field7: SnapshotSize
    field8: OverlapSize
    field9: NumTargets
    value0: '10000'
    value1: '10000000'
    value10: 2**10
    value11: '"/tmp"'
    value12: '"measure_X310_TwinRX_relative_phase_offsets_245.cfg"'
    value2: '2450000000'
    value3: '"ip:192.168.3.2"'
    value4: '60'
    value5: '4'
    value6: '0.5'
    value7: 2**11
    value8: 2**9
    value9: '1'
  states: {}
- name: norm_spacing
  id: variable
  parameters:
    value: '0.500'
  states: {}
- name: num_array_elements
  id: variable
  parameters:
    value: '4'
  states: {}
- name: num_targets
  id: variable
  parameters:
    value: '1'
  states: {}
- name: overlap_size
  id: variable
  parameters:
    value: '512'
  states: {}
- name: pspectrum_length
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: rel_phase_offsets_file_name
  id: variable
  parameters:
    value: os.path.join(directory_config_files, relative_phase_offset)
  states: {}
- name: relative_phase_offset
  id: variable
  parameters:
    value: '"FMCOMMS5_relative_phase_offsets.cfg"'
  states: {}
- name: rx_addr
  id: variable
  parameters:
    value: '"ip:192.168.3.2"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '10000000'
  states: {}
- name: snapshot_size
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: tone_freq
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: CARES_phase_correct_hier_0
  id: CARES_phase_correct_hier
  parameters:
    config_filename: rel_phase_offsets_file_name
    num_ports: num_array_elements
  states: {}
- name: aoa_MUSIC_lin_array_0
  id: aoa_MUSIC_lin_array
  parameters:
    norm_spacing: norm_spacing
    num_inputs: int(numpy.sqrt(num_array_elements))
    num_targets: num_targets
    pspectrum_len: pspectrum_length
  states: {}
- name: aoa_MUSIC_lin_array_0_0
  id: aoa_MUSIC_lin_array
  parameters:
    norm_spacing: norm_spacing
    num_inputs: int(numpy.sqrt(num_array_elements))
    num_targets: num_targets
    pspectrum_len: pspectrum_length
  states: {}
- name: aoa_MUSIC_lin_array_0_0_0
  id: aoa_MUSIC_lin_array
  parameters:
    norm_spacing: norm_spacing
    num_inputs: int(numpy.sqrt(num_array_elements))
    num_targets: num_targets
    pspectrum_len: pspectrum_length
  states: {}
- name: aoa_MUSIC_lin_array_0_0_0_0
  id: aoa_MUSIC_lin_array
  parameters:
    norm_spacing: norm_spacing
    num_inputs: int(numpy.sqrt(num_array_elements))
    num_targets: num_targets
    pspectrum_len: pspectrum_length
  states: {}
- name: aoa_autocorrelate_0
  id: aoa_autocorrelate
  parameters:
    avg_method: '1'
    num_inputs: int(numpy.sqrt(num_array_elements))
    overlap_size: overlap_size
    snapshot_size: snapshot_size
  states: {}
- name: aoa_autocorrelate_0_0
  id: aoa_autocorrelate
  parameters:
    avg_method: '1'
    num_inputs: int(numpy.sqrt(num_array_elements))
    overlap_size: overlap_size
    snapshot_size: snapshot_size
  states: {}
- name: aoa_autocorrelate_0_0_0
  id: aoa_autocorrelate
  parameters:
    avg_method: '1'
    num_inputs: int(numpy.sqrt(num_array_elements))
    overlap_size: overlap_size
    snapshot_size: snapshot_size
  states: {}
- name: aoa_autocorrelate_0_0_0_0
  id: aoa_autocorrelate
  parameters:
    avg_method: '1'
    num_inputs: int(numpy.sqrt(num_array_elements))
    overlap_size: overlap_size
    snapshot_size: snapshot_size
  states: {}
- name: iio_fmcomms5_source_0
  id: iio_fmcomms5_source
  parameters:
    bandwidth: samp_rate
    bbdc: 'True'
    buffer_size: '0x8000'
    filter: ''
    frequency1: center_freq
    frequency2: center_freq
    gain1: '''manual'''
    gain2: '''manual'''
    gain3: '''manual'''
    gain4: '''manual'''
    manual_gain1: gain
    manual_gain2: gain
    manual_gain3: gain
    manual_gain4: gain
    quadrature: 'True'
    rf_port_select: '''A_BALANCED'''
    rfdc: 'True'
    rx1_en: 'True'
    rx2_en: 'True'
    rx3_en: 'True'
    rx4_en: 'True'
    samplerate: samp_rate
    uri: input_variables.RxAddr
  states: {}
- name: import
  id: import
  parameters:
    imports: import os, numpy
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    grid: 'True'
    gui_hint: tab@0
    showports: 'True'
    update_time: '0.05'
    vlen: pspectrum_length
    width1: '2'
    x_axis_label: '"angle (in degrees)"'
    x_start: '0'
    x_step: 180/pspectrum_length
    y_axis_label: '"Pseudo-Spectrum (dB)"'
    ymax: '0'
    ymin: '-20'
  states: {}
- name: qtgui_vector_sink_f_0_0
  id: qtgui_vector_sink_f
  parameters:
    grid: 'True'
    gui_hint: tab@0
    showports: 'True'
    update_time: '0.05'
    vlen: pspectrum_length
    width1: '2'
    x_axis_label: '"angle (in degrees)"'
    x_start: '0'
    x_step: 180/pspectrum_length
    y_axis_label: '"Pseudo-Spectrum (dB)"'
    ymax: '0'
    ymin: '-20'
  states: {}
- name: qtgui_vector_sink_f_0_0_0
  id: qtgui_vector_sink_f
  parameters:
    grid: 'True'
    gui_hint: tab@0
    showports: 'True'
    update_time: '0.05'
    vlen: pspectrum_length
    width1: '2'
    x_axis_label: '"angle (in degrees)"'
    x_start: '0'
    x_step: 180/pspectrum_length
    y_axis_label: '"Pseudo-Spectrum (dB)"'
    ymax: '0'
    ymin: '-20'
  states: {}
- name: qtgui_vector_sink_f_0_0_0_0
  id: qtgui_vector_sink_f
  parameters:
    grid: 'True'
    gui_hint: tab@0
    showports: 'True'
    update_time: '0.05'
    vlen: pspectrum_length
    width1: '2'
    x_axis_label: '"angle (in degrees)"'
    x_start: '0'
    x_step: 180/pspectrum_length
    y_axis_label: '"Pseudo-Spectrum (dB)"'
    ymax: '0'
    ymin: '-20'
  states: {}
- name: tab
  id: qtgui_tab_widget
  parameters:
    label0: Pseudo-Spectrum
    label1: Angle of Arrival (MUSIC)
    num_tabs: '2'
  states: {}

connections:
- [CARES_phase_correct_hier_0, '0', aoa_autocorrelate_0, '0']
- [CARES_phase_correct_hier_0, '0', aoa_autocorrelate_0_0_0, '0']
- [CARES_phase_correct_hier_0, '1', aoa_autocorrelate_0, '1']
- [CARES_phase_correct_hier_0, '1', aoa_autocorrelate_0_0, '0']
- [CARES_phase_correct_hier_0, '2', aoa_autocorrelate_0_0_0, '1']
- [CARES_phase_correct_hier_0, '2', aoa_autocorrelate_0_0_0_0, '0']
- [CARES_phase_correct_hier_0, '3', aoa_autocorrelate_0_0, '1']
- [CARES_phase_correct_hier_0, '3', aoa_autocorrelate_0_0_0_0, '1']
- [aoa_MUSIC_lin_array_0, '0', qtgui_vector_sink_f_0, '0']
- [aoa_MUSIC_lin_array_0_0, '0', qtgui_vector_sink_f_0_0_0, '0']
- [aoa_MUSIC_lin_array_0_0_0, '0', qtgui_vector_sink_f_0_0_0_0, '0']
- [aoa_MUSIC_lin_array_0_0_0_0, '0', qtgui_vector_sink_f_0_0, '0']
- [aoa_autocorrelate_0, '0', aoa_MUSIC_lin_array_0, '0']
- [aoa_autocorrelate_0_0, '0', aoa_MUSIC_lin_array_0_0, '0']
- [aoa_autocorrelate_0_0_0, '0', aoa_MUSIC_lin_array_0_0_0, '0']
- [aoa_autocorrelate_0_0_0_0, '0', aoa_MUSIC_lin_array_0_0_0_0, '0']
- [iio_fmcomms5_source_0, '0', CARES_phase_correct_hier_0, '0']
- [iio_fmcomms5_source_0, '1', CARES_phase_correct_hier_0, '1']
- [iio_fmcomms5_source_0, '2', CARES_phase_correct_hier_0, '2']
- [iio_fmcomms5_source_0, '3', CARES_phase_correct_hier_0, '3']

metadata:
  file_format: 1
