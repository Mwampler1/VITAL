options:
  parameters:
    generate_options: no_gui
    id: calibrate_lin_array_X310_TwinRX
    output_language: python
    run_options: run
  states: {}

blocks:
- name: antenna_calibration
  id: variable
  parameters:
    value: '"FMCOMMS5_calibration.cfg"'
  states: {}
- name: antenna_calibration_file_name
  id: variable
  parameters:
    value: os.path.join(directory_config_files, antenna_calibration)
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '2450000000'
  states: {}
- name: directory_config_files
  id: variable
  parameters:
    value: '"/tmp"'
  states: {}
- name: gain
  id: variable
  parameters:
    value: '60'
  states: {}
- name: input_variables
  id: variable_struct
  parameters:
    comment: |-
      input_variables: 
      Contains all the user-defined variables.
    field0: ToneFreq
    field1: SampleRate
    field10: DirectoryConfigFiles
    field11: RelativePhaseOffsets
    field12: AntennaCalibration
    field13: Samples2Avg
    field2: CenterFreq
    field3: RxAddr
    field4: Gain
    field5: NumArrayElements
    field6: NormSpacing
    field7: SnapshotSize
    field8: OverlapSize
    field9: PilotAngle
    value0: '10000'
    value1: '10000000'
    value10: '"/tmp"'
    value11: '"measure_X310_TwinRX_relative_phase_offsets_245.cfg"'
    value12: '"calibration_lin_array_245.cfg"'
    value13: 2**11
    value2: '2450000000'
    value3: '"addr=192.168.10.2"'
    value4: '60'
    value5: '4'
    value6: '0.5'
    value7: 2**11
    value8: 2**9
    value9: '45.0'
  states: {}
- name: norm_spacing
  id: variable
  parameters:
    value: '0.500'
  states: {}
- name: num_array_elements
  id: variable
  parameters:
    value: '4'
  states: {}
- name: overlap_size
  id: variable
  parameters:
    value: '512'
  states: {}
- name: pilot_angle
  id: variable
  parameters:
    value: '45'
  states: {}
- name: rel_phase_offsets_file_name
  id: variable
  parameters:
    value: os.path.join(directory_config_files, relative_phase_offset)
  states: {}
- name: relative_phase_offset
  id: variable
  parameters:
    value: '"FMCOMMS5_relative_phase_offsets.cfg"'
  states: {}
- name: rx_adder
  id: variable
  parameters:
    value: '"addr=192.168.10.2"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '10000000'
  states: {}
- name: samples_2_avg
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: snapshot_size
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: tone_freq
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: CARES_calibrate_lin_array_0
  id: CARES_calibrate_lin_array
  parameters:
    norm_spacing: norm_spacing
    num_ant_ele: num_array_elements
    pilot_angle: pilot_angle
  states: {}
- name: CARES_phase_correct_hier_0
  id: CARES_phase_correct_hier
  parameters:
    config_filename: relative_phase_offsets_file_name
    num_ports: num_array_elements
  states: {}
- name: CARES_save_antenna_calib_0
  id: CARES_save_antenna_calib
  parameters:
    config_filename: antenna_calibration_file_name
    num_inputs: num_array_elements
    samples_to_average: samples_2_avg
  states: {}
- name: aoa_autocorrelate_0
  id: aoa_autocorrelate
  parameters:
    avg_method: '1'
    num_inputs: num_array_elements
    overlap_size: overlap_size
    snapshot_size: snapshot_size
  states: {}
- name: blocks_complex_to_magphase_0
  id: blocks_complex_to_magphase
  parameters:
    vlen: num_array_elements
  states: {}
- name: iio_fmcomms5_source_0_0
  id: iio_fmcomms5_source
  parameters:
    bandwidth: samp_rate
    bbdc: 'True'
    buffer_size: '0x8000'
    filter: ''
    frequency1: center_freq
    frequency2: center_freq
    gain1: '''manual'''
    gain2: '''manual'''
    gain3: '''manual'''
    gain4: '''manual'''
    manual_gain1: gain
    manual_gain2: gain
    manual_gain3: gain
    manual_gain4: gain
    quadrature: 'True'
    rf_port_select: '''A_BALANCED'''
    rfdc: 'True'
    rx1_en: 'True'
    rx2_en: 'True'
    rx3_en: 'True'
    rx4_en: 'True'
    samplerate: samp_rate
    uri: ip:192.168.3.2
  states: {}
- name: import
  id: import
  parameters:
    imports: import os
  states: {}

connections:
- [CARES_calibrate_lin_array_0, '0', blocks_complex_to_magphase_0, '0']
- [CARES_phase_correct_hier_0, '0', aoa_autocorrelate_0, '0']
- [CARES_phase_correct_hier_0, '1', aoa_autocorrelate_0, '1']
- [CARES_phase_correct_hier_0, '2', aoa_autocorrelate_0, '2']
- [CARES_phase_correct_hier_0, '3', aoa_autocorrelate_0, '3']
- [aoa_autocorrelate_0, '0', CARES_calibrate_lin_array_0, '0']
- [blocks_complex_to_magphase_0, '0', CARES_save_antenna_calib_0, '0']
- [blocks_complex_to_magphase_0, '1', CARES_save_antenna_calib_0, '1']
- [iio_fmcomms5_source_0_0, '0', CARES_phase_correct_hier_0, '0']
- [iio_fmcomms5_source_0_0, '1', CARES_phase_correct_hier_0, '1']
- [iio_fmcomms5_source_0_0, '2', CARES_phase_correct_hier_0, '2']
- [iio_fmcomms5_source_0_0, '3', CARES_phase_correct_hier_0, '3']

metadata:
  file_format: 1
