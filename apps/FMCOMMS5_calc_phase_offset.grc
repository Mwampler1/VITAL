options:
  parameters:
    generate_options: qt_gui
    id: estimate_X310_TwinRX_constant_phase_offsets_and_save
    output_language: python
    run_options: run
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: '2450000000'
  states: {}
- name: directory_config_files
  id: variable
  parameters:
    value: '"/tmp"'
  states: {}
- name: gain
  id: variable
  parameters:
    value: '60'
  states: {}
- name: input_variables
  id: variable_struct
  parameters:
    comment: |-
      input_variables: 
      Contains all the user-defined variables.
    field0: SampleRate
    field1: ToneFreq
    field2: CenterFreq
    field3: Gain
    field4: NumArrayElements
    field5: RxAddr
    field6: DirectoryConfigFiles
    field7: RelativePhaseOffsets
    field8: SkipAhead
    field9: Samples2FindMax
    value0: '10000000'
    value1: '10000'
    value2: '2450000000'
    value3: '60'
    value4: '4'
    value5: '"addr=192.168.10.2"'
    value6: '"/tmp"'
    value7: '"measure_X310_TwinRX_relative_phase_offsets_245.cfg"'
    value8: 2**15
    value9: 2**11
  states: {state: disabled}
- name: num_array_elements
  id: variable
  parameters:
    value: '4'
  states: {}
- name: rel_phase_offsets_file_name
  id: variable
  parameters:
    value: os.path.join(directory_config_files, relative_phase_offset_files)
  states: {}
- name: relative_phase_offset_files
  id: variable
  parameters:
    value: '"FMCOMMS5_relative_phase_offsets.cfg"'
  states: {}
- name: rx_addr
  id: variable
  parameters:
    value: '"addr=192.168.10.2"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '10000000'
  states: {}
- name: samples_2_find_max
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: skip_ahead
  id: variable
  parameters:
    value: '32768'
  states: {}
- name: tone_freq
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: CARES_findmax_and_save_0
  id: CARES_findmax_and_save
  parameters:
    config_filename: /tmp/phases.cfg
    num_inputs: num_array_elements - 1
    samples_to_findmax: samples_2_find_max
  states: {state: disabled}
- name: CARES_twinrx_phase_offset_est_0
  id: CARES_twinrx_phase_offset_est
  parameters:
    n_skip_ahead: skip_ahead
    num_inputs: num_array_elements
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: '"IIO_FMCOMMS5_relative_phase_offsets.cfg"'
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_float_to_complex_1
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_float_to_complex_2
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_float_to_complex_3
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_short_to_float_1
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_short_to_float_2
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_short_to_float_3
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_short_to_float_4
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_short_to_float_5
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_short_to_float_6
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_short_to_float_7
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: iio_device_source_0
  id: iio_device_source
  parameters:
    buffer_size: '32768'
    channels: '["voltage0", "voltage1", "voltage2", "voltage3", "voltage4", "voltage5", "voltage6", "voltage7"]'
    decimation: '1'
    device: '"cf-ad9361-A"'
    device_phy: '"ad9361-phy"'
    params: '[]'
    uri: '"ip:analog.local"'
  states: {state: disabled}
- name: iio_fmcomms5_source_0
  id: iio_fmcomms5_source
  parameters:
    bandwidth: samp_rate
    bbdc: 'True'
    buffer_size: '0x8000'
    filter: ''
    frequency1: center_freq
    frequency2: center_freq
    gain1: '''manual'''
    gain2: '''manual'''
    gain3: '''manual'''
    gain4: '''manual'''
    manual_gain1: gain
    manual_gain2: gain
    manual_gain3: gain
    manual_gain4: gain
    quadrature: 'True'
    rf_port_select: '''A_BALANCED'''
    rfdc: 'True'
    rx1_en: 'True'
    rx2_en: 'True'
    rx3_en: 'True'
    rx4_en: 'True'
    samplerate: samp_rate
    uri: '"10.23.23.40"'
  states: {}
- name: import
  id: import
  parameters:
    imports: import os
  states: {}

connections:
- [CARES_twinrx_phase_offset_est_0, '0', CARES_findmax_and_save_0, '0']
- [CARES_twinrx_phase_offset_est_0, '0', blocks_file_sink_0, '0']
- [CARES_twinrx_phase_offset_est_0, '1', CARES_findmax_and_save_0, '1']
- [CARES_twinrx_phase_offset_est_0, '1', blocks_null_sink_0, '0']
- [CARES_twinrx_phase_offset_est_0, '2', CARES_findmax_and_save_0, '2']
- [CARES_twinrx_phase_offset_est_0, '2', blocks_null_sink_0_0, '0']
- [blocks_short_to_float_0, '0', blocks_float_to_complex_2, '1']
- [blocks_short_to_float_1, '0', blocks_float_to_complex_2, '0']
- [blocks_short_to_float_2, '0', blocks_float_to_complex_1, '0']
- [blocks_short_to_float_3, '0', blocks_float_to_complex_1, '1']
- [blocks_short_to_float_4, '0', blocks_float_to_complex_0, '1']
- [blocks_short_to_float_5, '0', blocks_float_to_complex_0, '0']
- [blocks_short_to_float_6, '0', blocks_float_to_complex_3, '0']
- [blocks_short_to_float_7, '0', blocks_float_to_complex_3, '1']
- [iio_device_source_0, '0', blocks_short_to_float_5, '0']
- [iio_device_source_0, '1', blocks_short_to_float_4, '0']
- [iio_device_source_0, '2', blocks_short_to_float_1, '0']
- [iio_device_source_0, '3', blocks_short_to_float_0, '0']
- [iio_device_source_0, '4', blocks_short_to_float_2, '0']
- [iio_device_source_0, '5', blocks_short_to_float_3, '0']
- [iio_device_source_0, '6', blocks_short_to_float_6, '0']
- [iio_device_source_0, '7', blocks_short_to_float_7, '0']
- [iio_fmcomms5_source_0, '0', CARES_twinrx_phase_offset_est_0, '0']
- [iio_fmcomms5_source_0, '1', CARES_twinrx_phase_offset_est_0, '1']
- [iio_fmcomms5_source_0, '2', CARES_twinrx_phase_offset_est_0, '2']
- [iio_fmcomms5_source_0, '3', CARES_twinrx_phase_offset_est_0, '3']

metadata:
  file_format: 1
