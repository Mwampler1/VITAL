options:
  parameters:
    generate_options: qt_gui
    id: run_MUSIC_lin_array_X310_TwinRX
    output_language: python
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: '2450000000'
  states: {}
- name: directory_config_files
  id: variable
  parameters:
    value: '"/tmp"'
  states: {}
- name: gain
  id: variable
  parameters:
    value: '60'
  states: {}
- name: input_variables
  id: variable_struct
  parameters:
    comment: |-
      input_variables: 
      Contains all the user-defined variables.
    field0: ToneFreq
    field1: SampleRate
    field10: PSpectrumLength
    field11: DirectoryConfigFiles
    field12: RelativePhaseOffsets
    field2: CenterFreq
    field3: RxAddr
    field4: Gain
    field5: NumArrayElements
    field6: NormSpacing
    field7: SnapshotSize
    field8: OverlapSize
    field9: NumTargets
    value0: '10000'
    value1: '10000000'
    value10: 2**10
    value11: '"/tmp"'
    value12: '"measure_X310_TwinRX_relative_phase_offsets_245.cfg"'
    value2: '2450000000'
    value3: '"ip:192.168.3.2"'
    value4: '60'
    value5: '4'
    value6: '0.5'
    value7: 2**11
    value8: 2**9
    value9: '1'
  states: {}
- name: norm_spacing
  id: variable
  parameters:
    value: '0.500'
  states: {}
- name: num_array_elements
  id: variable
  parameters:
    value: '4'
  states: {}
- name: num_targets
  id: variable
  parameters:
    value: '1'
  states: {}
- name: overlap_size
  id: variable
  parameters:
    value: '512'
  states: {}
- name: pspectrum_length
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: rel_phase_offsets_file_name
  id: variable
  parameters:
    value: os.path.join(directory_config_files, relative_phase_offset)
  states: {}
- name: relative_phase_offset
  id: variable
  parameters:
    value: '"FMCOMMS5_relative_phase_offsets.cfg"'
  states: {}
- name: rx_addr
  id: variable
  parameters:
    value: '"ip:192.168.3.2"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '10000000'
  states: {}
- name: snapshot_size
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: tone_freq
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: CARES_MUSIC_lin_array_0
  id: CARES_MUSIC_lin_array
  parameters:
    norm_spacing: norm_spacing
    num_inputs: num_array_elements
    num_targets: num_targets
    pspectrum_len: pspectrum_length
  states: {}
- name: CARES_antenna_correction_0
  id: CARES_antenna_correction
  parameters:
    config_filename: /tmp/antenna.cfg
    num_inputs: num_array_elements
  states: {}
- name: CARES_autocorrelate_0
  id: CARES_autocorrelate
  parameters:
    avg_method: '1'
    num_inputs: num_array_elements
    overlap_size: overlap_size
    snapshot_size: snapshot_size
  states: {}
- name: CARES_find_local_max_0
  id: CARES_find_local_max
  parameters:
    num_max_vals: num_targets
    vector_len: pspectrum_length
    x_max: '180.0'
    x_min: '0.0'
  states: {}
- name: CARES_phase_correct_hier_0
  id: CARES_phase_correct_hier
  parameters:
    config_filename: rel_phase_offsets_file_name
    num_ports: num_array_elements
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_float_to_complex_1
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_float_to_complex_2
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_float_to_complex_3
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
    vlen: num_targets
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_short_to_float_1
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_short_to_float_2
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_short_to_float_3
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_short_to_float_4
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_short_to_float_5
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_short_to_float_6
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_short_to_float_7
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: iio_device_source_0
  id: iio_device_source
  parameters:
    buffer_size: '32768'
    channels: '["voltage0", "voltage1", "voltage2", "voltage3", "voltage4", "voltage5", "voltage6", "voltage7"]'
    decimation: '1'
    device: '"cf-ad9361-A"'
    device_phy: '"ad9361-phy"'
    params: '[]'
    uri: '"ip:analog.local"'
  states: {state: disabled}
- name: iio_fmcomms5_source_0
  id: iio_fmcomms5_source
  parameters:
    bandwidth: samp_rate
    bbdc: 'True'
    buffer_size: '0x8000'
    filter: ''
    frequency1: center_freq
    frequency2: center_freq
    gain1: '''manual'''
    gain2: '''manual'''
    gain3: '''manual'''
    gain4: '''manual'''
    manual_gain1: gain
    manual_gain2: gain
    manual_gain3: gain
    manual_gain4: gain
    quadrature: 'True'
    rf_port_select: '''A_BALANCED'''
    rfdc: 'True'
    rx1_en: 'True'
    rx2_en: 'True'
    rx3_en: 'True'
    rx4_en: 'True'
    samplerate: samp_rate
    uri: '"ip:analog.local"'
  states: {}
- name: import
  id: import
  parameters:
    imports: import os
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    grid: 'True'
    showports: 'True'
    update_time: '0.05'
    vlen: pspectrum_length
    width1: '2'
    x_axis_label: '"angle (in degrees)"'
    x_start: '0'
    x_step: 180/pspectrum_length
    y_axis_label: '"Pseudo-Spectrum (dB)"'
    ymax: '0'
    ymin: '-20'
  states: {}

connections:
- [CARES_MUSIC_lin_array_0, '0', CARES_find_local_max_0, '0']
- [CARES_MUSIC_lin_array_0, '0', qtgui_vector_sink_f_0, '0']
- [CARES_antenna_correction_0, '0', CARES_autocorrelate_0, '0']
- [CARES_antenna_correction_0, '1', CARES_autocorrelate_0, '1']
- [CARES_antenna_correction_0, '2', CARES_autocorrelate_0, '2']
- [CARES_antenna_correction_0, '3', CARES_autocorrelate_0, '3']
- [CARES_autocorrelate_0, '0', CARES_MUSIC_lin_array_0, '0']
- [CARES_find_local_max_0, '0', blocks_null_sink_0, '0']
- [CARES_find_local_max_0, '1', qtgui_number_sink_0, '0']
- [CARES_phase_correct_hier_0, '0', CARES_antenna_correction_0, '0']
- [CARES_phase_correct_hier_0, '1', CARES_antenna_correction_0, '1']
- [CARES_phase_correct_hier_0, '2', CARES_antenna_correction_0, '2']
- [CARES_phase_correct_hier_0, '3', CARES_antenna_correction_0, '3']
- [blocks_short_to_float_0, '0', blocks_float_to_complex_2, '1']
- [blocks_short_to_float_1, '0', blocks_float_to_complex_2, '0']
- [blocks_short_to_float_2, '0', blocks_float_to_complex_1, '0']
- [blocks_short_to_float_3, '0', blocks_float_to_complex_1, '1']
- [blocks_short_to_float_4, '0', blocks_float_to_complex_0, '1']
- [blocks_short_to_float_5, '0', blocks_float_to_complex_0, '0']
- [blocks_short_to_float_6, '0', blocks_float_to_complex_3, '0']
- [blocks_short_to_float_7, '0', blocks_float_to_complex_3, '1']
- [iio_device_source_0, '0', blocks_short_to_float_5, '0']
- [iio_device_source_0, '1', blocks_short_to_float_4, '0']
- [iio_device_source_0, '2', blocks_short_to_float_1, '0']
- [iio_device_source_0, '3', blocks_short_to_float_0, '0']
- [iio_device_source_0, '4', blocks_short_to_float_2, '0']
- [iio_device_source_0, '5', blocks_short_to_float_3, '0']
- [iio_device_source_0, '6', blocks_short_to_float_6, '0']
- [iio_device_source_0, '7', blocks_short_to_float_7, '0']
- [iio_fmcomms5_source_0, '0', CARES_phase_correct_hier_0, '0']
- [iio_fmcomms5_source_0, '1', CARES_phase_correct_hier_0, '1']
- [iio_fmcomms5_source_0, '2', CARES_phase_correct_hier_0, '2']
- [iio_fmcomms5_source_0, '3', CARES_phase_correct_hier_0, '3']

metadata:
  file_format: 1
