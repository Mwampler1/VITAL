options:
  parameters:
    generate_options: no_gui
    id: calibrate_lin_array_X310_TwinRX
    output_language: python
    run_options: run
  states: {}

blocks:
- name: antenna_calibration
  id: variable
  parameters:
    value: '"FMCOMMS5_calibration.cfg"'
  states: {}
- name: antenna_calibration_file_name
  id: variable
  parameters:
    value: os.path.join(directory_config_files, antenna_calibration)
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '2450000000'
  states: {}
- name: directory_config_files
  id: variable
  parameters:
    value: '"/tmp"'
  states: {}
- name: gain
  id: variable
  parameters:
    value: '60'
  states: {}
- name: norm_spacing
  id: variable
  parameters:
    value: '0.500'
  states: {}
- name: num_array_elements
  id: variable
  parameters:
    value: '4'
  states: {}
- name: overlap_size
  id: variable
  parameters:
    value: '512'
  states: {}
- name: pilot_angle
  id: variable
  parameters:
    value: '45'
  states: {}
- name: rel_phase_offsets_file_name
  id: variable
  parameters:
    value: os.path.join(directory_config_files, relative_phase_offset)
  states: {}
- name: relative_phase_offset
  id: variable
  parameters:
    value: '"FMCOMMS5_relative_phase_offsets.cfg"'
  states: {}
- name: rx_adder
  id: variable
  parameters:
    value: '"addr=192.168.10.2"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '10000000'
  states: {}
- name: samples_2_avg
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: snapshot_size
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: tone_freq
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: CARES_autocorrelate_0
  id: CARES_autocorrelate
  parameters:
    avg_method: '1'
    num_inputs: num_array_elements
    overlap_size: overlap_size
    snapshot_size: snapshot_size
  states: {}
- name: CARES_calibrate_lin_array_0
  id: CARES_calibrate_lin_array
  parameters:
    norm_spacing: norm_spacing
    num_ant_ele: num_array_elements
    pilot_angle: pilot_angle
  states: {}
- name: CARES_phase_correct_hier_0
  id: CARES_phase_correct_hier
  parameters:
    config_filename: relative_phase_offsets_file_name
    num_ports: num_array_elements
  states: {}
- name: CARES_save_antenna_calib_0
  id: CARES_save_antenna_calib
  parameters:
    config_filename: antenna_calibration_file_name
    num_inputs: num_array_elements
    samples_to_average: samples_2_avg
  states: {}
- name: blocks_complex_to_magphase_0
  id: blocks_complex_to_magphase
  parameters:
    vlen: num_array_elements
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_float_to_complex_1
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_float_to_complex_2
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_float_to_complex_3
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_short_to_float_1
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_short_to_float_2
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_short_to_float_3
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_short_to_float_4
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_short_to_float_5
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_short_to_float_6
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_short_to_float_7
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: iio_device_source_0
  id: iio_device_source
  parameters:
    buffer_size: '32768'
    channels: '["voltage0", "voltage1", "voltage2", "voltage3", "voltage4", "voltage5", "voltage6", "voltage7"]'
    decimation: '1'
    device: '"cf-ad9361-A"'
    device_phy: '"ad9361-phy"'
    params: '[]'
    uri: '"ip:analog.local"'
  states: {state: disabled}
- name: iio_fmcomms5_source_0_0
  id: iio_fmcomms5_source
  parameters:
    bandwidth: samp_rate
    bbdc: 'True'
    buffer_size: '0x8000'
    filter: ''
    frequency1: center_freq
    frequency2: center_freq
    gain1: '''manual'''
    gain2: '''manual'''
    gain3: '''manual'''
    gain4: '''manual'''
    manual_gain1: gain
    manual_gain2: gain
    manual_gain3: gain
    manual_gain4: gain
    quadrature: 'True'
    rf_port_select: '''A_BALANCED'''
    rfdc: 'True'
    rx1_en: 'True'
    rx2_en: 'True'
    rx3_en: 'True'
    rx4_en: 'True'
    samplerate: samp_rate
    uri: '"ip:analog.local"'
  states: {}
- name: import
  id: import
  parameters:
    imports: import os
  states: {}

connections:
- [CARES_autocorrelate_0, '0', CARES_calibrate_lin_array_0, '0']
- [CARES_calibrate_lin_array_0, '0', blocks_complex_to_magphase_0, '0']
- [CARES_phase_correct_hier_0, '0', CARES_autocorrelate_0, '0']
- [CARES_phase_correct_hier_0, '1', CARES_autocorrelate_0, '1']
- [CARES_phase_correct_hier_0, '2', CARES_autocorrelate_0, '2']
- [CARES_phase_correct_hier_0, '3', CARES_autocorrelate_0, '3']
- [blocks_complex_to_magphase_0, '0', CARES_save_antenna_calib_0, '0']
- [blocks_complex_to_magphase_0, '1', CARES_save_antenna_calib_0, '1']
- [blocks_short_to_float_0, '0', blocks_float_to_complex_2, '1']
- [blocks_short_to_float_1, '0', blocks_float_to_complex_2, '0']
- [blocks_short_to_float_2, '0', blocks_float_to_complex_1, '0']
- [blocks_short_to_float_3, '0', blocks_float_to_complex_1, '1']
- [blocks_short_to_float_4, '0', blocks_float_to_complex_0, '1']
- [blocks_short_to_float_5, '0', blocks_float_to_complex_0, '0']
- [blocks_short_to_float_6, '0', blocks_float_to_complex_3, '0']
- [blocks_short_to_float_7, '0', blocks_float_to_complex_3, '1']
- [iio_device_source_0, '0', blocks_short_to_float_5, '0']
- [iio_device_source_0, '1', blocks_short_to_float_4, '0']
- [iio_device_source_0, '2', blocks_short_to_float_1, '0']
- [iio_device_source_0, '3', blocks_short_to_float_0, '0']
- [iio_device_source_0, '4', blocks_short_to_float_2, '0']
- [iio_device_source_0, '5', blocks_short_to_float_3, '0']
- [iio_device_source_0, '6', blocks_short_to_float_6, '0']
- [iio_device_source_0, '7', blocks_short_to_float_7, '0']
- [iio_fmcomms5_source_0_0, '0', CARES_phase_correct_hier_0, '0']
- [iio_fmcomms5_source_0_0, '1', CARES_phase_correct_hier_0, '1']
- [iio_fmcomms5_source_0_0, '2', CARES_phase_correct_hier_0, '2']
- [iio_fmcomms5_source_0_0, '3', CARES_phase_correct_hier_0, '3']

metadata:
  file_format: 1
