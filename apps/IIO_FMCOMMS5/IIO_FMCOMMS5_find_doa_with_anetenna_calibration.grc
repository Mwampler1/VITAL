options:
  parameters:
    description: 'From doa: run_MUSIC_lin_array_X310_TwinRX'
    generate_options: qt_gui
    id: IIO_FMCOMMS5_find_doa_with_anetenna_calibration
    output_language: python
    title: IIO_FMCOMMS5_find_doa_with_anetenna_calibration
  states: {}

blocks:
- name: antenna_calibration
  id: variable
  parameters:
    value: '"IIO_FMCOMMS5_antenna_calibration.cfg"'
  states: {}
- name: antenna_calibration_file_name
  id: variable
  parameters:
    value: os.path.join(directory_config_files, antenna_calibration)
  states: {}
- name: directory_config_files
  id: variable
  parameters:
    value: '"/home/rtp/rtp/GNU-Radio/gr-CARES/apps/IIO_FMCOMMS5/"'
  states: {}
- name: input_variables
  id: variable_struct
  parameters:
    comment: |-
      input_variables: 
      Contains all the user-defined variables.
    field0: ToneFreq
    field1: SampleRate
    field10: PSpectrumLength
    field11: DirectoryConfigFiles
    field12: RelativePhaseOffsets
    field2: CenterFreq
    field3: RxAddr
    field4: Gain
    field5: NumArrayElements
    field6: NormSpacing
    field7: SnapshotSize
    field8: OverlapSize
    field9: NumTargets
    value0: '10000'
    value1: '10000000'
    value10: 2**10
    value11: '"/tmp"'
    value12: '"measure_X310_TwinRX_relative_phase_offsets_245.cfg"'
    value2: '2450000000'
    value3: '"ip:192.168.3.2"'
    value4: '60'
    value5: '4'
    value6: '0.5'
    value7: 2**11
    value8: 2**9
    value9: '1'
  states: {}
- name: norm_spacing
  id: variable
  parameters:
    value: '0.500'
  states: {}
- name: num_array_elements
  id: variable
  parameters:
    value: '4'
  states: {}
- name: num_targets
  id: variable
  parameters:
    value: '1'
  states: {}
- name: overlap_size
  id: variable
  parameters:
    value: '512'
  states: {}
- name: pspectrum_length
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: rel_phase_offsets_file_name
  id: variable
  parameters:
    value: os.path.join(directory_config_files, relative_phase_offset_files)
  states: {}
- name: relative_phase_offset_files
  id: variable
  parameters:
    value: '"IIO_FMCOMMS5_relative_phase_offsets.txt"'
  states: {}
- name: snapshot_size
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: CARES_MUSIC_lin_array_0
  id: CARES_MUSIC_lin_array
  parameters:
    norm_spacing: norm_spacing
    num_inputs: num_array_elements
    num_targets: num_targets
    pspectrum_len: pspectrum_length
  states: {}
- name: CARES_antenna_correction_0
  id: CARES_antenna_correction
  parameters:
    config_filename: antenna_calibration_file_name
    num_inputs: num_array_elements
  states: {}
- name: CARES_autocorrelate_0
  id: CARES_autocorrelate
  parameters:
    avg_method: '1'
    num_inputs: num_array_elements
    overlap_size: overlap_size
    snapshot_size: snapshot_size
  states: {}
- name: CARES_find_local_max_0
  id: CARES_find_local_max
  parameters:
    num_max_vals: num_targets
    vector_len: pspectrum_length
    x_max: '180.0'
    x_min: '0.0'
  states: {}
- name: CARES_phase_correct_hier_0
  id: CARES_phase_correct_hier
  parameters:
    config_filename: rel_phase_offsets_file_name
    num_ports: num_array_elements
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/rtp/rtp/GNU-Radio/gr-CARES/apps/IIO_FMCOMMS5/degrees
    type: float
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/rtp/rtp/GNU-Radio/gr-CARES/apps/IIO_FMCOMMS5/degreeshoriz
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
    vlen: num_targets
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_short_to_float_0_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_short_to_float_0_0_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_short_to_float_0_0_1
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_short_to_float_0_1
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_short_to_float_0_1_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_short_to_float_0_1_0_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_short_to_float_0_2
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: iio_device_source_0
  id: iio_device_source
  parameters:
    buffer_size: '32768'
    channels: '["voltage0","voltage1", "voltage2", "voltage3", "voltage4", "voltage5", "voltage6", "voltage7"]'
    decimation: '1'
    device: '"cf-ad9361-A"'
    device_phy: '"ad9361-phy"'
    params: '[]'
    uri: '"10.23.23.44"'
  states: {}
- name: import
  id: import
  parameters:
    imports: import os
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    grid: 'True'
    gui_hint: tab@0
    name: '"vertical"'
    showports: 'True'
    update_time: '0.05'
    vlen: pspectrum_length
    width1: '2'
    x_axis_label: '"angle (in degrees)"'
    x_start: '0'
    x_step: 180/pspectrum_length
    y_axis_label: '"Pseudo-Spectrum (dB)"'
    ymax: '0'
    ymin: '-20'
  states: {}
- name: qtgui_vector_sink_f_0_0
  id: qtgui_vector_sink_f
  parameters:
    average: '0.2'
    grid: 'True'
    gui_hint: tab@0
    name: '"horizontal"'
    showports: 'True'
    update_time: '0.05'
    vlen: pspectrum_length
    width1: '2'
    x_axis_label: '"Pseudo-Spectrum (dB)"'
    x_start: '-20'
    x_step: '0'
    y_axis_label: '"angle (in degrees)"'
    ymax: '180'
    ymin: '0'
  states: {state: disabled}
- name: tab
  id: qtgui_tab_widget
  parameters:
    label0: Pseudo-Spectrum
    label1: Angle of Arrival (MUSIC)
    num_tabs: '2'
  states: {}

connections:
- [CARES_MUSIC_lin_array_0, '0', CARES_find_local_max_0, '0']
- [CARES_MUSIC_lin_array_0, '0', qtgui_vector_sink_f_0, '0']
- [CARES_MUSIC_lin_array_0, '0', qtgui_vector_sink_f_0_0, '0']
- [CARES_antenna_correction_0, '0', CARES_autocorrelate_0, '0']
- [CARES_antenna_correction_0, '1', CARES_autocorrelate_0, '1']
- [CARES_antenna_correction_0, '2', CARES_autocorrelate_0, '2']
- [CARES_antenna_correction_0, '3', CARES_autocorrelate_0, '3']
- [CARES_autocorrelate_0, '0', CARES_MUSIC_lin_array_0, '0']
- [CARES_find_local_max_0, '0', blocks_null_sink_0, '0']
- [CARES_find_local_max_0, '1', blocks_file_sink_0, '0']
- [CARES_find_local_max_0, '1', blocks_file_sink_0_0, '0']
- [CARES_find_local_max_0, '1', qtgui_number_sink_0, '0']
- [CARES_phase_correct_hier_0, '0', CARES_antenna_correction_0, '0']
- [CARES_phase_correct_hier_0, '1', CARES_antenna_correction_0, '1']
- [CARES_phase_correct_hier_0, '2', CARES_antenna_correction_0, '2']
- [CARES_phase_correct_hier_0, '3', CARES_antenna_correction_0, '3']
- [blocks_float_to_complex_0, '0', CARES_phase_correct_hier_0, '0']
- [blocks_float_to_complex_0_0, '0', CARES_phase_correct_hier_0, '1']
- [blocks_float_to_complex_0_0_0, '0', CARES_phase_correct_hier_0, '2']
- [blocks_float_to_complex_0_0_0_0, '0', CARES_phase_correct_hier_0, '3']
- [blocks_short_to_float_0, '0', blocks_float_to_complex_0, '0']
- [blocks_short_to_float_0_0, '0', blocks_float_to_complex_0, '1']
- [blocks_short_to_float_0_0_0, '0', blocks_float_to_complex_0_0, '1']
- [blocks_short_to_float_0_0_1, '0', blocks_float_to_complex_0_0_0, '1']
- [blocks_short_to_float_0_1, '0', blocks_float_to_complex_0_0, '0']
- [blocks_short_to_float_0_1_0, '0', blocks_float_to_complex_0_0_0_0, '0']
- [blocks_short_to_float_0_1_0_0, '0', blocks_float_to_complex_0_0_0_0, '1']
- [blocks_short_to_float_0_2, '0', blocks_float_to_complex_0_0_0, '0']
- [iio_device_source_0, '0', blocks_short_to_float_0, '0']
- [iio_device_source_0, '1', blocks_short_to_float_0_0, '0']
- [iio_device_source_0, '2', blocks_short_to_float_0_1, '0']
- [iio_device_source_0, '3', blocks_short_to_float_0_0_0, '0']
- [iio_device_source_0, '4', blocks_short_to_float_0_2, '0']
- [iio_device_source_0, '5', blocks_short_to_float_0_0_1, '0']
- [iio_device_source_0, '6', blocks_short_to_float_0_1_0, '0']
- [iio_device_source_0, '7', blocks_short_to_float_0_1_0_0, '0']

metadata:
  file_format: 1
