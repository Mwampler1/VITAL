options:
  parameters:
    author: megan
    description: 'From doa: view_X310_TwinRX_op_with_corrected_phase_offsets'
    generate_options: qt_gui
    id: IIO_FMCOMMS5_view_corrected_phase_offsets
    output_language: python
    title: IIO_FMCOMMS5_view_corrected_phase_offsets
  states: {}

blocks:
- name: directory_config_files
  id: variable
  parameters:
    value: '"/home/rtp/rtp/GNU-Radio/gr-CARES/apps/IIO_FMCOMMS5/"'
  states: {}
- name: rel_phase_offsets_file_name
  id: variable
  parameters:
    value: os.path.join(directory_config_files, relative_phase_offset_files)
  states: {}
- name: relative_phase_offset_files
  id: variable
  parameters:
    value: '"IIO_FMCOMMS5_relative_phase_offsets.txt"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '10000000'
  states: {}
- name: CARES_phase_correct_hier_0
  id: CARES_phase_correct_hier
  parameters:
    config_filename: rel_phase_offsets_file_name
    num_ports: '4'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_short_to_float_0_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_short_to_float_0_0_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_short_to_float_0_0_1
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_short_to_float_0_1
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_short_to_float_0_1_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_short_to_float_0_1_0_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_short_to_float_0_2
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: iio_device_source_0
  id: iio_device_source
  parameters:
    buffer_size: '32768'
    channels: '["voltage0","voltage1", "voltage2", "voltage3", "voltage4", "voltage5", "voltage6", "voltage7"]'
    decimation: '1'
    device: '"cf-ad9361-A"'
    device_phy: '"ad9361-phy"'
    params: '[]'
    uri: '"10.23.23.40"'
  states: {}
- name: import
  id: import
  parameters:
    imports: import os
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    nconnections: '4'
    size: '1024'
    srate: samp_rate
    type: complex
    update_time: '0.5'
  states: {}

connections:
- [CARES_phase_correct_hier_0, '0', qtgui_time_sink_x_0, '0']
- [CARES_phase_correct_hier_0, '1', qtgui_time_sink_x_0, '1']
- [CARES_phase_correct_hier_0, '2', qtgui_time_sink_x_0, '2']
- [CARES_phase_correct_hier_0, '3', qtgui_time_sink_x_0, '3']
- [blocks_float_to_complex_0, '0', CARES_phase_correct_hier_0, '0']
- [blocks_float_to_complex_0_0, '0', CARES_phase_correct_hier_0, '1']
- [blocks_float_to_complex_0_0_0, '0', CARES_phase_correct_hier_0, '2']
- [blocks_float_to_complex_0_0_0_0, '0', CARES_phase_correct_hier_0, '3']
- [blocks_short_to_float_0, '0', blocks_float_to_complex_0, '0']
- [blocks_short_to_float_0_0, '0', blocks_float_to_complex_0, '1']
- [blocks_short_to_float_0_0_0, '0', blocks_float_to_complex_0_0, '1']
- [blocks_short_to_float_0_0_1, '0', blocks_float_to_complex_0_0_0, '1']
- [blocks_short_to_float_0_1, '0', blocks_float_to_complex_0_0, '0']
- [blocks_short_to_float_0_1_0, '0', blocks_float_to_complex_0_0_0_0, '0']
- [blocks_short_to_float_0_1_0_0, '0', blocks_float_to_complex_0_0_0_0, '1']
- [blocks_short_to_float_0_2, '0', blocks_float_to_complex_0_0_0, '0']
- [iio_device_source_0, '0', blocks_short_to_float_0, '0']
- [iio_device_source_0, '1', blocks_short_to_float_0_0, '0']
- [iio_device_source_0, '2', blocks_short_to_float_0_1, '0']
- [iio_device_source_0, '3', blocks_short_to_float_0_0_0, '0']
- [iio_device_source_0, '4', blocks_short_to_float_0_2, '0']
- [iio_device_source_0, '5', blocks_short_to_float_0_0_1, '0']
- [iio_device_source_0, '6', blocks_short_to_float_0_1_0, '0']
- [iio_device_source_0, '7', blocks_short_to_float_0_1_0_0, '0']

metadata:
  file_format: 1
