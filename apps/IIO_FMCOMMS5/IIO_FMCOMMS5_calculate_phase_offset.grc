options:
  parameters:
    description: 'From DOA: estimate_X310_TwinRX_constant_phase_offsets_and_save'
    generate_options: no_gui
    id: IIO_FMCOMMS5_calculate_phase_offset
    output_language: python
    run_options: run
    title: IIO_FMCOMMS5_calculate_phase_offset
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: '2450000000'
  states: {}
- name: directory_config_files
  id: variable
  parameters:
    value: '"/home/rtp/rtp/GNU-Radio/gr-CARES/apps/IIO_FMCOMMS5/"'
  states: {}
- name: file2
  id: variable
  parameters:
    value: '"IIO_FMCOMMS5_relative_phase_offsets_2.txt"'
  states: {}
- name: file3
  id: variable
  parameters:
    value: '"IIO_FMCOMMS5_relative_phase_offsets_3.txt"'
  states: {}
- name: filepath2
  id: variable
  parameters:
    value: '"/home/rtp/rtp/GNU-Radio/gr-CARES/apps/IIO_FMCOMMS5/"'
  states: {}
- name: filepath3
  id: variable
  parameters:
    value: '"/home/rtp/rtp/GNU-Radio/gr-CARES/apps/IIO_FMCOMMS5/"'
  states: {}
- name: filepathfinal2
  id: variable
  parameters:
    value: os.path.join(filepath2, file2)
  states: {}
- name: filepathfinal3
  id: variable
  parameters:
    value: os.path.join(filepath3, file3)
  states: {}
- name: input_variables
  id: variable_struct
  parameters:
    comment: |-
      input_variables: 
      Contains all the user-defined variables.
    field0: SampleRate
    field1: ToneFreq
    field2: CenterFreq
    field3: Gain
    field4: NumArrayElements
    field5: RxAddr
    field6: DirectoryConfigFiles
    field7: RelativePhaseOffsets
    field8: SkipAhead
    field9: Samples2FindMax
    value0: '10000000'
    value1: '10000'
    value2: '2450000000'
    value3: '60'
    value4: '4'
    value5: '"addr=192.168.10.2"'
    value6: '"/tmp"'
    value7: '"measure_X310_TwinRX_relative_phase_offsets_245.cfg"'
    value8: 2**15
    value9: 2**11
  states: {state: disabled}
- name: num_array_elements
  id: variable
  parameters:
    value: '4'
  states: {}
- name: rel_phase_offsets_file_name
  id: variable
  parameters:
    value: os.path.join(directory_config_files, relative_phase_offset_files)
  states: {}
- name: relative_phase_offset_files
  id: variable
  parameters:
    value: '"IIO_FMCOMMS5_relative_phase_offsets_1.txt"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '10000000'
  states: {}
- name: samples_2_find_max
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: skip_ahead
  id: variable
  parameters:
    value: '32768'
  states: {}
- name: tone_freq
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: CARES_findmax_and_save_0
  id: CARES_findmax_and_save
  parameters:
    config_filename: rel_phase_offsets_file_name
    num_inputs: num_array_elements - 1
    samples_to_findmax: samples_2_find_max
  states: {state: disabled}
- name: CARES_findmax_and_save_0_0
  id: CARES_findmax_and_save
  parameters:
    config_filename: rel_phase_offsets_file_name
    num_inputs: '1'
    samples_to_findmax: samples_2_find_max
  states: {}
- name: CARES_findmax_and_save_0_0_0
  id: CARES_findmax_and_save
  parameters:
    config_filename: filepathfinal2
    num_inputs: '1'
    samples_to_findmax: samples_2_find_max
  states: {}
- name: CARES_findmax_and_save_0_0_0_0
  id: CARES_findmax_and_save
  parameters:
    config_filename: filepathfinal3
    num_inputs: '1'
    samples_to_findmax: samples_2_find_max
  states: {}
- name: CARES_twinrx_phase_offset_est_0
  id: CARES_twinrx_phase_offset_est
  parameters:
    n_skip_ahead: skip_ahead
    num_inputs: num_array_elements
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_short_to_float_0_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_short_to_float_0_0_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_short_to_float_0_0_1
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_short_to_float_0_1
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_short_to_float_0_1_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_short_to_float_0_1_0_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_short_to_float_0_2
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: iio_device_source_0
  id: iio_device_source
  parameters:
    buffer_size: '32768'
    channels: '["voltage0","voltage1", "voltage2", "voltage3", "voltage4", "voltage5", "voltage6", "voltage7"]'
    decimation: '1'
    device: '"cf-ad9361-A"'
    device_phy: '"ad9361-phy"'
    params: '[]'
    uri: '"10.23.23.40"'
  states: {}
- name: import
  id: import
  parameters:
    imports: import os
  states: {}

connections:
- [CARES_twinrx_phase_offset_est_0, '0', CARES_findmax_and_save_0, '0']
- [CARES_twinrx_phase_offset_est_0, '0', CARES_findmax_and_save_0_0, '0']
- [CARES_twinrx_phase_offset_est_0, '1', CARES_findmax_and_save_0, '1']
- [CARES_twinrx_phase_offset_est_0, '1', CARES_findmax_and_save_0_0_0, '0']
- [CARES_twinrx_phase_offset_est_0, '2', CARES_findmax_and_save_0, '2']
- [CARES_twinrx_phase_offset_est_0, '2', CARES_findmax_and_save_0_0_0_0, '0']
- [blocks_float_to_complex_0, '0', CARES_twinrx_phase_offset_est_0, '0']
- [blocks_float_to_complex_0_0, '0', CARES_twinrx_phase_offset_est_0, '1']
- [blocks_float_to_complex_0_0_0, '0', CARES_twinrx_phase_offset_est_0, '2']
- [blocks_float_to_complex_0_0_0_0, '0', CARES_twinrx_phase_offset_est_0, '3']
- [blocks_short_to_float_0, '0', blocks_float_to_complex_0, '0']
- [blocks_short_to_float_0_0, '0', blocks_float_to_complex_0, '1']
- [blocks_short_to_float_0_0_0, '0', blocks_float_to_complex_0_0, '1']
- [blocks_short_to_float_0_0_1, '0', blocks_float_to_complex_0_0_0, '1']
- [blocks_short_to_float_0_1, '0', blocks_float_to_complex_0_0, '0']
- [blocks_short_to_float_0_1_0, '0', blocks_float_to_complex_0_0_0_0, '0']
- [blocks_short_to_float_0_1_0_0, '0', blocks_float_to_complex_0_0_0_0, '1']
- [blocks_short_to_float_0_2, '0', blocks_float_to_complex_0_0_0, '0']
- [iio_device_source_0, '0', blocks_short_to_float_0, '0']
- [iio_device_source_0, '1', blocks_short_to_float_0_0, '0']
- [iio_device_source_0, '2', blocks_short_to_float_0_1, '0']
- [iio_device_source_0, '3', blocks_short_to_float_0_0_0, '0']
- [iio_device_source_0, '4', blocks_short_to_float_0_2, '0']
- [iio_device_source_0, '5', blocks_short_to_float_0_0_1, '0']
- [iio_device_source_0, '6', blocks_short_to_float_0_1_0, '0']
- [iio_device_source_0, '7', blocks_short_to_float_0_1_0_0, '0']

metadata:
  file_format: 1
